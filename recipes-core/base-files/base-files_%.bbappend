# look for files in this layer first

hostname = "canyon-mx8mp"
