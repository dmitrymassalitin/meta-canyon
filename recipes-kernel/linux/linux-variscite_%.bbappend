FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Make-copy-of-the-Linux-kernel-s-devicetree.patch file://0002-Make-copy-of-the-Linux-kernel-s-devicetree.patch"

