SRCREV = "3a11efa3a025abb581e0af8c072437a9a5f1e4c3"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Make-copy-of-the-imx8mp_var_dart-board-to-canyon_mx8.patch"

